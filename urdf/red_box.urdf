Commit message: update

File: urdf/red_box.urdf (robot description, URDF)
Before this commit: robot red_box, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.1 0.075 0.025; visual box size=0.1 0.075 0.025
